Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-8080-24-000 + Ekko Ceiling Raft Hanging Frame + Snap Key Hook Assembly.IFC
Time: 2024-11-22T16:49:17+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 15.3203524761245795; Volume Measure: 0.0150982092718345; Area Measure: 2.7181430688352464

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 15.3203524761245795; Volume Measure: 0.0150982092718345; Area Measure: 2.7181430688352464

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 15.3203524761245795; Volume Measure: 0.0150982092718345; Area Measure: 2.7181430688352464

# IfcBuildingElementProxy (15)
In: default BuildingStorey
Name
ER-SGNP-8080-24-000 + Ekko Ceiling Raft Hanging Frame + Snap Key Hook Assembly.SLDPRT | PSet_Mass_Property - Mass Measure: 15.3203524761245795; Volume Measure: 0.0150982092718345; Area Measure: 2.7181430688352464
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly
4 x Snap Key Hook +Wire Cable+Cable Gripper | SOLIDWORKS Custom Properties - Nomenclature: hook lock; Part Number: hook lock; Source: NOT_KNOWN; Revision: ANY; sets with these values: 2
4 x Wire Cable +Snap Key Hook
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-1
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-2
ER-SGNP-8080-24-000 Seigen
EKKO CEILING RAFT HANGING FRAME
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-3
