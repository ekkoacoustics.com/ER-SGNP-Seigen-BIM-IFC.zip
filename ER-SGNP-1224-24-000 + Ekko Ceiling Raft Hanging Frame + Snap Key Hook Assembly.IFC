Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-1224-24-000 + Ekko Ceiling Raft Hanging Frame + Snap Key Hook Assembly.IFC
Time: 2024-11-22T16:53:19+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 69.0297707819697166; Volume Measure: 0.0685854843733896; Area Measure: 11.9145996155779894

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 69.0297707819697166; Volume Measure: 0.0685854843733896; Area Measure: 11.9145996155779894

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 69.0297707819697166; Volume Measure: 0.0685854843733896; Area Measure: 11.9145996155779894

# IfcBuildingElementProxy (28)
In: default BuildingStorey
Name
ER-SGNP-1224-24-000 + Ekko Ceiling Raft Hanging Frame + Snap Key Hook Assembly.SLDPRT | PSet_Mass_Property - Mass Measure: 69.0297707819697166; Volume Measure: 0.0685854843733896; Area Measure: 11.9145996155779894
EKKO CEILING RAFT HANGING FRAME
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly
8 x Snap Key Hook +Wire Cable+Cable Gripper | SOLIDWORKS Custom Properties - Nomenclature: hook lock; Part Number: hook lock; Source: NOT_KNOWN; Revision: ANY; sets with these values: 2
8 x Wire Cable +Snap Key Hook
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-1
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-2
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-3
ER-SGNP-1224-24-000 Seigen
EKKO CEILING RAFT HANGING FRAME-1
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-4
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-5
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-6
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-7
