Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-1260-24-000 Seigen.IFC
Time: 2024-11-22T16:48:32+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 17.0510881400406333; Volume Measure: 0.0170510881400406; Area Measure: 2.9239047568576213

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 17.0510881400406333; Volume Measure: 0.0170510881400406; Area Measure: 2.9239047568576213

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 17.0510881400406333; Volume Measure: 0.0170510881400406; Area Measure: 2.9239047568576213

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ER-SGNP-1260-24-000 Seigen | PSet_Mass_Property - Mass Measure: 17.0510881400406333; Volume Measure: 0.0170510881400406; Area Measure: 2.9239047568576213
ER-SGNP-1260-24-000 Seigen
