Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-1224-24-000 Seigen.IFC
Time: 2024-11-22T16:47:06+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 68.2959289474461997; Volume Measure: 0.0682959289474462; Area Measure: 11.6048141140488266

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 68.2959289474461997; Volume Measure: 0.0682959289474462; Area Measure: 11.6048141140488266

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 68.2959289474461997; Volume Measure: 0.0682959289474462; Area Measure: 11.6048141140488266

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ER-SGNP-1224-24-000 Seigen | PSet_Mass_Property - Mass Measure: 68.2959289474461997; Volume Measure: 0.0682959289474462; Area Measure: 11.6048141140488266
ER-SGNP-1224-24-000 Seigen
