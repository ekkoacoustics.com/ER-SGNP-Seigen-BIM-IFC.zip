Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-1212-24-000 Seigen.IFC
Time: 2024-11-22T16:46:20+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 33.7359289474461974; Volume Measure: 0.0337359289474462; Area Measure: 5.7296141140488270

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 33.7359289474461974; Volume Measure: 0.0337359289474462; Area Measure: 5.7296141140488270

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 33.7359289474461974; Volume Measure: 0.0337359289474462; Area Measure: 5.7296141140488270

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ER-SGNP-1212-24-000 Seigen | PSet_Mass_Property - Mass Measure: 33.7359289474461974; Volume Measure: 0.0337359289474462; Area Measure: 5.7296141140488270
ER-SGNP-1212-24-000 Seigen
