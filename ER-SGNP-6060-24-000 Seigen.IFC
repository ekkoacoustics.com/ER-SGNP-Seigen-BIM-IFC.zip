Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-6060-24-000 Seigen.IFC
Time: 2024-11-22T16:50:41+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 8.4110881400406363; Volume Measure: 0.0084110881400406; Area Measure: 1.4551047568576216

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 8.4110881400406363; Volume Measure: 0.0084110881400406; Area Measure: 1.4551047568576216

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 8.4110881400406363; Volume Measure: 0.0084110881400406; Area Measure: 1.4551047568576216

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ER-SGNP-6060-24-000 Seigen | PSet_Mass_Property - Mass Measure: 8.4110881400406363; Volume Measure: 0.0084110881400406; Area Measure: 1.4551047568576216
ER-SGNP-6060-24-000 Seigen
