Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-8080-24-000 Seigen.IFC
Time: 2024-11-22T16:49:54+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 14.9534315588628033; Volume Measure: 0.0149534315588628; Area Measure: 2.5632503180706618

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 14.9534315588628033; Volume Measure: 0.0149534315588628; Area Measure: 2.5632503180706618

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 14.9534315588628033; Volume Measure: 0.0149534315588628; Area Measure: 2.5632503180706618

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ER-SGNP-8080-24-000 Seigen | PSet_Mass_Property - Mass Measure: 14.9534315588628033; Volume Measure: 0.0149534315588628; Area Measure: 2.5632503180706618
ER-SGNP-8080-24-000 Seigen
