Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-1214-24-000 Seigen.IFC
Time: 2024-11-22T16:47:42+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 39.4959289474462025; Volume Measure: 0.0394959289474462; Area Measure: 6.6992141140488277

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 39.4959289474462025; Volume Measure: 0.0394959289474462; Area Measure: 6.6992141140488277

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 39.4959289474462025; Volume Measure: 0.0394959289474462; Area Measure: 6.6992141140488277

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ER-SGNP-1214-24-000 Seigen | PSet_Mass_Property - Mass Measure: 39.4959289474462025; Volume Measure: 0.0394959289474462; Area Measure: 6.6992141140488277
ER-SGNP-1214-24-000 Seigen
