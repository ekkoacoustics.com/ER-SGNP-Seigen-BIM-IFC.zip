Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Seigen\ER-SGNP-1214-24-000 + Ekko Ceiling Raft Hanging Frame + Snap Key Hook Assembly.IFC
Time: 2024-11-22T16:51:14+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 40.2297707819697408; Volume Measure: 0.0397854843733897; Area Measure: 7.0089996155779977

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 40.2297707819697408; Volume Measure: 0.0397854843733897; Area Measure: 7.0089996155779977

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 40.2297707819697408; Volume Measure: 0.0397854843733897; Area Measure: 7.0089996155779977

# IfcBuildingElementProxy (28)
In: default BuildingStorey
Name
ER-SGNP-1214-24-000 + Ekko Ceiling Raft Hanging Frame + Snap Key Hook Assembly.SLDPRT | PSet_Mass_Property - Mass Measure: 40.2297707819697408; Volume Measure: 0.0397854843733897; Area Measure: 7.0089996155779977
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly
8 x Snap Key Hook +Wire Cable+Cable Gripper | SOLIDWORKS Custom Properties - Nomenclature: hook lock; Part Number: hook lock; Source: NOT_KNOWN; Revision: ANY; sets with these values: 2
8 x Wire Cable +Snap Key Hook
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-1
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-2
ER-SGNP-1214-24-000 Seigen
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-3
EKKO CEILING RAFT HANGING FRAME
EKKO CEILING RAFT HANGING FRAME-1
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-4
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-5
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-6
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly-7
